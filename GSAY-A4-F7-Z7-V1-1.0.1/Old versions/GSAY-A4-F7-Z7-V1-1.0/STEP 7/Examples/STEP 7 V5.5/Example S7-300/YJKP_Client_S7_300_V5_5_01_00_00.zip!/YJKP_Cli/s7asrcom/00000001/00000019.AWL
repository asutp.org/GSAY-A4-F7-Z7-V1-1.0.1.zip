TYPE "EN_AccessType"
VERSION : 0.1


  STRUCT
   READ : BYTE ;	//Read object
   WRITE : BYTE  := B#16#1;	//Write object
  END_STRUCT ;
END_TYPE

