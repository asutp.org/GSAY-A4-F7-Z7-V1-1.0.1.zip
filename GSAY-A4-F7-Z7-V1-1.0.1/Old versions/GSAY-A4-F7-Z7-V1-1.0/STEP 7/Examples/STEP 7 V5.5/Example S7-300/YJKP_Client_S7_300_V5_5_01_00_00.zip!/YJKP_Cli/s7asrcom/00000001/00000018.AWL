TYPE "EN_AccessOption"
VERSION : 0.1


  STRUCT
   SINGLE : BYTE ;	//Single read/write object
   MULTI : BYTE  := B#16#1;	//Multi read/write object
  END_STRUCT ;
END_TYPE

