TYPE "EN_MotionMode"
VERSION : 0.1


  STRUCT
   JOG : BYTE ;	//Jog
   ABSOLUTE : BYTE  := B#16#1;	//Move absolute
   RELATIVE : BYTE  := B#16#2;	//Move relative
  END_STRUCT ;
END_TYPE

