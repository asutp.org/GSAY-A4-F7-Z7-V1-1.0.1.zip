TYPE "EN_ComMode"
VERSION : 0.1


  STRUCT
   ACYCLIC : BYTE ;	//Acyclic communication mode
   CYCLIC : BYTE  := B#16#1;	//Cyclic communication mode
  END_STRUCT ;
END_TYPE

